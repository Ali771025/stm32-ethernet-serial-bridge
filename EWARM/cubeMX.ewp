# IAR project cubeMX.ewp, settings and files
configuration cubeMX (ARM, debug)
  General.OGChipSelectEditMenu: STM32H723VG ST STM32H723VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H723xx; USE_FULL_ASSERT; U8B_BOARD_ROLE=1U; U8B_BUILD_DEBUG=1
  ICCARM.CCIncludePath2: ../Core/Inc; ../App/Inc; ../Platform/Inc; ../Protocol/Inc; ../Bridge/Inc; ../Drivers/Uart/Inc; ../Drivers/BSP/Components/lan8742; ../Net/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../LWIP/App; ../LWIP/Target; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc; ../LWIP/App; ../LWIP/Target; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/BSP/Components/lan8742; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: cubeMX.hex
  ILINK.IlinkOutputFile: cubeMX.out
  ILINK.IlinkIcfFile: stm32h723xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H723xx; USE_FULL_ASSERT; U8B_BOARD_ROLE=1U; U8B_BUILD_RELEASE=1
  AARM.AUserIncludes: ../Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
configuration Debug_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H723xx; USE_FULL_ASSERT; U8B_BOARD_ROLE=2U; U8B_BUILD_DEBUG=1
  AARM.AUserIncludes: as above
configuration Release_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H723xx; USE_FULL_ASSERT; U8B_BOARD_ROLE=2U; U8B_BUILD_RELEASE=1
  AARM.AUserIncludes: as above
  group (top)
    ../STM32CubeIDE/: STM32H723VGTX_FLASH.ld STM32H723VGTX_RAM.ld
  group Application/EWARM
    ./: startup_stm32h723xx.s
  group Application/User/App
    ../App/Src/: app_baseline.c
  group Application/User/Bridge
    ../Bridge/Src/: u8b_backpressure.c u8b_basic_path.c u8b_reliable.c
  group Application/User/Core
    ../Core/Src/: freertos.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Application/User/Net
    ../Net/Src/: net_bridge.c net_diag.c
  group Application/User/Platform
    ../Platform/Src/: board_config.c platform_diagnostics.c platform_fault.c platform_reset.c platform_session.c platform_supervisor.c
  group Application/User/Protocol
    ../Protocol/Src/: u8b_protocol.c
  group Application/User/Uart
    ../Drivers/Uart/Src/: byte_ring.c uart_round_robin.c uart_service.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
